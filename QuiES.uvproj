# Keil uVision project QuiES.uvproj, settings and files
target QuiES (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: QuiES
  AfterMake: fromelf --bin --output .\rvmdk\timers.bin .\rvmdk\timers.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: timers.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S motors.c main.c giroacel.c serial.c QuIES_utils.c sonar.c motion.c control.c pid.c
    ./drivers/: buttons.c
    ./sensorlib/: mpu6050.c i2cm_drv.c
  group Libraries
    driverlib/rvmdk/: driverlib.lib
    ./sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
